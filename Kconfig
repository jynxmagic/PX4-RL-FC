## Kconfig
```kconfig
menuconfig EXAMPLES_RECORD
	bool "record"
	default n
	---help---
		Enable support for reinforcement learning flight controller
```
